Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-06T14:11:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 06 14:11:02 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{F6207843-181A-49A0-A44F-4116BFEC5CD0}\ifc * Database version: 5507 * Database creation date: Tue Jul 06 14:11:01 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 06 14:11:01 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 06 14:11:01 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28419854_RU_10391440_PUR98W_EDST, 10391440_RU_PUR98W_EDST:28419854_RU_10391440_PUR98W_EDST:207558
In: Level 1
Type - Classification: WAND-DEKOR DA (Uniformat); Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 28419854_RU_10391440_PUR98W_EDST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
